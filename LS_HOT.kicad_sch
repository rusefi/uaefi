File: LS_HOT.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U6 VNLD5160TR-E

Commit message: #66
Other:
- company: rusefi.com -> rusEFI.com
- title: UAEF Low Side always hot -> UAEFI
